# Repository 2Moons-JP/SharkPCB

## KiCad design kicadFiles/shark.kicad_pcb

Schematic: shark.kicad_sch, SharkPCB

Parts:
C1, C2, C11: 100n; C_0805_2012Metric
C3, C4, C5, C9: 100n; C_0402_1005Metric
C6, C10: 4.7u; C_0402_1005Metric
C7: 1u; C_0402_1005Metric
C8: 10n; C_0402_1005Metric
C12, C13: 1u; CP_EIA-3216-10_Kemet-I_Pad1.58x1.35mm_HandSolder
C14: 10u; C_0805_2012Metric
C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26: 100n; C_0805_2012Metric; Rating MLCC 0805 10V or more
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D52: 1N4148W; D_SOD-123
D51: RB060M-60TR; D_SOD-123; Manufacturer Part Number RB060M-60TR; LCSC Part Number C114257
D53, D54, D55, D56, D57, D58, D59, D60, D61, D62: WS2812C; LED_WS2812B_5.0x5.0mm_P3.2mm; Manufacturer Part Number WS2812C; LCSC Part Number C114587
F1: mSMD110-16V; Fuse_1812_4532Metric; Manufacturer Part Number mSMD110-16V; LCSC Part Number C69691
GR1: MountingHole; shark
GR2: MountingHole; sharkLogo
H1: MountingHole_Pad; 9774030243R; Manufacturer Part No 9774010243R
H2, H3, H4, H5, H6: MountingHole; 9774030243R; Manufacturer Part No 9774025243R
J1: TYPE-C-31-M12_13; TYPE-C-31-M-12; Manufacturer Part Numer TYPE-C-31-M-12; LCSC Part Number C165948
J2: ARM JTAG; Conn_ARM_JTAG_SWD_6
L1, L2: 120R@100MHz; L_1206_3216Metric_Pad1.42x1.75mm_HandSolder; Manufacturer Part Number HCB3216KF-101T30; LCSC Part Number C127313
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED35, LED36, LED37, LED40, LED41, LED42, LED43, LED44, LED45, LED46, LED47, LED48, LED49, LED50, LED51, LED53, LED55: LED; LED_THT_2.54mm
Q1, Q3: DTC123JKAT146; SOT-23; Manufacturer Part Number DTC123JKAT146; LCSC Part Number C111724
Q2: AO3401A; SOT-23; Manufacturer Part Number AO3401A; LCSC Part Number C15127
Q4: MMBFJ270; SOT-23; Manufacturer Part Number MMBFJ270; LCSC Part Number C160435
R1, R2: 5.1k; R_SMD_1206
R3, R4, R5, R6, R61, R77: 10k; R_SMD_1206
R7, R13: 100R; R_SMD_1206
R8, R9: 100k; R_SMD_1206
R10: 330k; R_SMD_1206
R11: 1M; R_SMD_1206
R12: 1k; R_SMD_1206
R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R62, R64, R65, R66, R68, R70, R71, R72, R73, R74, R75, R76: 420R; R_SMD_1206
R30, R31, R32, R33, R34, R35, R36, R37, R38, R39: 5R; R_SMD_1206
ROT1, ROT2: EC11E1820402; ALPS_EC11E; Manufacturer Part Number EC11E1820402; LCSC Part Number C361167
S1: K2-1187SQ-A4SW-06; Manufacturer Part Number K2-1187SQ-A4SW-06; LCSC Part Number C92584
SW1: ESC; MX100
SW2, SW38: Q; MX100
SW3: W; MX100
SW4: E; MX100
SW5: R; MX100
SW6: T; MX100
SW7: Y; MX100
SW8: U; MX100
SW9: I; MX100
SW10: O; MX100
SW11: P; MX100
SW12: BKSP; MX100
SW13: TAB; MX100
SW14: A; MX100
SW15: S; MX100
SW16: D; MX100
SW17: F; MX100
SW18: G; MX100
SW19: H; MX100
SW20: J; MX100
SW21: K; MX100
SW22: L; MX100
SW23: COLON; MX100
SW24: QUOTE; MX100
SW25: SHIFT; MX100
SW26: Z; MX100
SW27: X; MX100
SW28: C; MX100
SW29: V; MX100
SW30: B; MX100
SW31: N; MX100
SW32: M; MX100
SW33: COMMA; MX100
SW34: DOT; MX100
SW35: SLSH; MX100
SW36: ENTER; MX100
SW37: CTRL; MX100
SW39: WIN; MX100
SW40: ALT; MX100
SW41: F1; MX100
SW42, SW43: SPC_100; MX100
SW44: F2; MX100
SW45: LEFT; MX100
SW46: DOWN; MX100
SW47: UP; MX100
SW48: RIGHT; MX100
SW49, SW50, SW51: SPC_200; MX200R
U1: STM32F072CBT6; LQFP-48_7x7mm_P0.5mm; Manufacturer Part Number STM32F072CBT6; LCSC Part Number C81720
U2: USBLC6-2SC6; SOT-23-6; Manufacturer Part Number USBLC6-2SC6; LCSC Part Number C7519
U3: MCP1700T-3302E/TT; SOT-23; Manufacturer Part Number MCP1700T-3302E/TT; LCSC Part Number C39051
U4: TXS0101; SOT-23-6; Manufacturer Part Number TXS0101DBVR; LCSC Part Number C132604

Connections:
3V3: C3.1, C4.1, C5.2, C6.2, C7.1, C8.1, C9.2, C10.2, C13.1, C15.2, D51.2 (A), J2.1, R3.1, R4.1, R9.1, R61.2, S1.1 (A), U1.1 (VBAT), U1.9 (VDDA), U1.24 (VDD), U1.36 (VDDIO2), U1.48 (VDD), U3.2 (VO), U4.1 (VCCA)
5V: C12.1, C16.1, D51.1 (K), F1.2, Q2.2 (S), R8.1, R12.2, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, U3.3 (VI), U4.6 (VCCB)
BOOT0: C14.2, R10.2, R11.2, R77.2, U1.44 (BOOT0)
C0: ROT1.S1, SW1.1 (Col), SW13.1 (Col), SW25.1 (Col), SW37.2 (Row)
C1: SW2.1 (Col), SW14.1 (Col), SW26.1 (Col), SW38.1 (Col)
C2: SW3.1 (Col), SW15.2 (Row), SW27.1 (Col), SW39.1 (Col)
C3: SW4.2 (Row), SW16.1 (Col), SW28.1 (Col), SW40.1 (Col)
C4: SW5.1 (Col), SW17.1 (Col), SW29.1 (Col), SW41.1 (Col)
C5: SW6.1 (Col), SW18.1 (Col), SW30.1 (Col), SW42.1 (Col), SW50.1 (Col)
C6: SW7.1 (Col), SW19.1 (Col), SW31.1 (Col), SW43.1 (Col), SW49.1 (Col), SW51.1 (Col)
C7: SW8.1 (Col), SW20.1 (Col), SW32.1 (Col), SW44.1 (Col)
C8: SW9.1 (Col), SW21.1 (Col), SW33.1 (Col), SW45.1 (Col)
C9: SW10.1 (Col), SW22.1 (Col), SW34.1 (Col), SW46.1 (Col)
C10: SW11.1 (Col), SW23.1 (Col), SW35.1 (Col), SW47.1 (Col)
C11: ROT2.S1, SW12.1 (Col), SW24.1 (Col), SW36.1 (Col), SW48.1 (Col)
D+: U1.33 (USB_DP/PA12), U2.1 (I/O1)
D-: U1.32 (USB_DM/TIM1_CH4/PA11), U2.3 (I/O2)
DB+: J1.A6 (D+), J1.B6 (D+), U2.6 (I/O1)
DB-: J1.A7 (D-), J1.B7 (D-), U2.4 (I/O2)
ENCA: R3.2, R5.1, ROT1.A, ROT2.A
ENCB: R4.2, R6.1, ROT1.B, ROT2.B
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.2, C8.2, C9.1, C10.1, C11.2, C12.2, C13.2, C14.1, C15.1, C16.2, C17.1, C18.1, C19.1, C20.1, C21.1, C22.2, C23.2, C24.2, C25.2, C26.2, D53.3 (VSS), D54.3 (VSS), D55.3 (VSS), D56.3 (VSS), D57.3 (VSS), D58.3 (VSS), D59.3 (VSS), D60.3 (VSS), D61.3 (VSS), D62.3 (VSS), J1.A1 (GND), J1.B1 (GND), J2.5, L1.1, L2.1, LED1.K, LED2.K, LED3.K, LED4.K, LED5.K, LED6.K, LED7.K, LED8.K, LED9.K, LED10.K, LED11.K, LED12.K, LED13.K, LED14.K, LED15.K, LED16.K, LED17.K, LED18.K, LED19.K, LED20.K, LED21.K, LED22.K, LED23.K, LED24.K, LED25.K, LED26.K, LED27.K, LED28.K, LED29.K, LED30.K, LED31.K, LED32.K, LED33.K, LED34.K, LED35.K, LED36.K, LED37.K, LED40.K, LED41.K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
GNDPWR: J1.S (SHIELD), L2.2
LED_PWM: Q3.1 (B), U1.16 (PA6/ADC_IN6/TIM3_CH1/TIM16_CH1)
NRST: C11.1, J2.3, R7.2, U1.7 (NRST)
unnamed: C17.2, D53.1 (VDD), R30.1
unnamed: C18.2, D54.1 (VDD), R31.1
unnamed: C19.2, D55.1 (VDD), R32.1
unnamed: C20.2, D56.1 (VDD), R33.1
unnamed: C21.2, D57.1 (VDD), R34.1
unnamed: C22.1, D58.1 (VDD), R35.1
unnamed: C23.1, D59.1 (VDD), R36.1
unnamed: C24.1, D60.1 (VDD), R37.1
unnamed: C25.1, D61.1 (VDD), R38.1
unnamed: C26.1, D62.1 (VDD), R39.1
unnamed: D2.2 (A), SW2.2 (Row)
unnamed: D3.2 (A), SW3.2 (Row)
unnamed: D4.2 (A), SW4.1 (Col)
unnamed: D5.2 (A), SW5.2 (Row)
unnamed: D6.2 (A), SW6.2 (Row)
unnamed: D7.2 (A), SW7.2 (Row)
unnamed: D8.2 (A), SW8.2 (Row)
unnamed: D9.2 (A), SW9.2 (Row)
unnamed: D10.2 (A), SW10.2 (Row)
unnamed: D11.2 (A), SW11.2 (Row)
unnamed: D13.2 (A), SW13.2 (Row)
unnamed: D14.2 (A), SW14.2 (Row)
unnamed: D15.2 (A), SW15.1 (Col)
unnamed: D16.2 (A), SW16.2 (Row)
unnamed: D17.2 (A), SW17.2 (Row)
unnamed: D18.2 (A), SW18.2 (Row)
unnamed: D19.2 (A), SW19.2 (Row)
unnamed: D20.2 (A), SW20.2 (Row)
unnamed: D21.2 (A), SW21.2 (Row)
unnamed: D22.2 (A), SW22.2 (Row)
unnamed: D23.2 (A), SW23.2 (Row)
unnamed: D24.2 (A), SW24.2 (Row)
unnamed: D25.2 (A), SW25.2 (Row)
unnamed: D26.2 (A), SW26.2 (Row)
unnamed: D27.2 (A), SW27.2 (Row)
unnamed: D28.2 (A), SW28.2 (Row)
unnamed: D29.2 (A), SW29.2 (Row)
unnamed: D30.2 (A), SW30.2 (Row)
unnamed: D31.2 (A), SW31.2 (Row)
unnamed: D32.2 (A), SW32.2 (Row)
unnamed: D33.2 (A), SW33.2 (Row)
unnamed: D34.2 (A), SW34.2 (Row)
unnamed: D35.2 (A), SW35.2 (Row)
unnamed: D36.2 (A), SW36.2 (Row)
unnamed: D37.2 (A), SW37.1 (Col)
unnamed: D38.2 (A), SW38.2 (Row)
unnamed: D39.2 (A), SW39.2 (Row)
unnamed: D40.2 (A), SW40.2 (Row)
unnamed: D41.2 (A), SW41.2 (Row)
unnamed: D42.2 (A), SW42.2 (Row), SW50.2 (Row)
unnamed: D43.2 (A), SW43.2 (Row), SW49.2 (Row), SW51.2 (Row)
unnamed: D44.2 (A), SW44.2 (Row)
unnamed: D45.2 (A), SW45.2 (Row)
unnamed: D46.2 (A), SW46.2 (Row)
unnamed: D47.2 (A), SW47.2 (Row)
unnamed: D48.2 (A), SW48.2 (Row)
unnamed: D49.2 (A), ROT1.C
unnamed: D50.2 (A), ROT2.C
unnamed: D52.1 (K), R10.1
unnamed: D52.2 (A), Q1.1 (B), Q4.3 (G), S1.2 (B)
unnamed: D53.2 (DOUT), D54.4 (DIN)
unnamed: D54.2 (DOUT), D55.4 (DIN)
unnamed: D55.2 (DOUT), D56.4 (DIN)
unnamed: D56.2 (DOUT), D57.4 (DIN)
unnamed: D57.2 (DOUT), D62.4 (DIN)
unnamed: D58.4 (DIN), D59.2 (DOUT)
unnamed: D59.4 (DIN), D60.2 (DOUT)
unnamed: D60.4 (DIN), D61.2 (DOUT)
unnamed: D61.4 (DIN), D62.2 (DOUT)
unnamed: H1.1, L1.2
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.B5 (CC2), R2.1
unnamed: LED1.A, R14.1
unnamed: LED2.A, R15.1
unnamed: LED3.A, R16.1
unnamed: LED4.A, R17.1
unnamed: LED5.A, R18.1
unnamed: LED6.A, R19.1
unnamed: LED7.A, R20.1
unnamed: LED8.A, R21.1
unnamed: LED9.A, R22.1
unnamed: LED10.A, R23.1
unnamed: LED11.A, R24.1
unnamed: LED12.A, R25.1
unnamed: LED13.A, R27.1
unnamed: LED14.A, R28.1
unnamed: LED15.A, R29.1
unnamed: LED16.A, R40.1
unnamed: LED17.A, R41.1
unnamed: LED18.A, R42.1
unnamed: LED19.A, R43.1
unnamed: LED20.A, R44.1
unnamed: LED21.A, R45.1
unnamed: LED22.A, R46.1
unnamed: LED23.A, R47.1
unnamed: LED24.A, R26.1
unnamed: LED25.A, R49.1
unnamed: LED26.A, R50.1
unnamed: LED27.A, R51.1
unnamed: LED28.A, R52.1
unnamed: LED29.A, R53.1
unnamed: LED30.A, R54.1
unnamed: LED31.A, R55.1
unnamed: LED32.A, R56.1
unnamed: LED33.A, R57.1
unnamed: LED34.A, R58.1
unnamed: LED35.A, R59.1
unnamed: LED36.A, R48.1
unnamed: LED37.A, R62.1
unnamed: LED40.A, R64.1
unnamed: LED41.A, R65.1
unnamed: LED42.A, LED43.A, R66.1
unnamed: LED44.A, LED45.A, R68.1
unnamed: LED46.A, R70.1
unnamed: LED47.A, LED49.A, R71.1
unnamed: LED48.A, R60.1
unnamed: LED50.A, R72.1
unnamed: LED51.A, R73.1
unnamed: LED53.A, R75.1
unnamed: LED55.A, R76.1
unnamed: Q1.3 (C), R7.1
unnamed: Q2.1 (G), R13.1
unnamed: Q2.3 (D), R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R40.2, R41.2, R42.2, R43.2, R44.2, R45.2, R46.2, R47.2, R48.2, R49.2, R50.2, R51.2, R52.2, R53.2, R54.2, R55.2, R56.2, R57.2, R58.2, R59.2, R60.2, R62.2, R64.2, R65.2, R66.2, R68.2, R70.2, R71.2, R72.2, R73.2, R74.2, R75.2, R76.2
unnamed: Q3.3 (C), R12.1, R13.2
unnamed: Q4.1 (D), R77.1
unnamed: R61.1, U4.5 (OE)
R0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K)
R1: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D49.1 (K)
R1_S2: D1.2 (A), ROT1.S2, SW1.2 (Row)
R2: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K)
R2_S2: D12.2 (A), ROT2.S2, SW12.2 (Row)
R3: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K)
R5: D50.1 (K)
RGB_3V3: U1.28 (SPI2_MOSI/I2S2_SD/PB15), U4.3 (A)
RGB_5V: D53.4 (DIN), U4.4 (B)
ROTA: C1.1, R5.2, U1.17 (PA7/TIM3_CH2/TIM14_CH1/ADC_IN7)
ROTB: C2.1, R6.2, U1.18 (PB0/TIM3_CH3/ADC_IN8)
SWCLK: J2.4, U1.37 (SWCLK/PA14)
SWDIO: J2.2, U1.34 (SWDIO/PA13)
VBUS: F1.1, J1.A4 (VBUS), J1.B4 (VBUS), U2.5 (VBUS)

Notes on the sheet:
3V3
HARD RESET
RGB BACKLIGHT
ENCODERS
LED

Board: 2 copper layers, 225.6 x 74.6 mm, 288 parts (1 on the bottom side), 164 nets.

## Commit log

2020-09-24 Reset circuit, level translator, SWD
2021-01-24 cache
